# Keil uVision project Master_Ctrl.uvprojx, settings and files
target Master_Ctrl (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Master_Ctrl +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\STM32_Lib;..\STM32_Lib\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\UserCode;..\UserCode\App;..\UserCode\DataOper;..\UserCode\DataOper\cJSON;..\UserCode\Driver\Bsp;..\UserCode\Driver\Sdcard;..\UserCode\Driver\Slusart;..\UserCode\Driver\Ethernet\W5500;..\UserCode\Driver\Ethernet;..\UserCode\Driver\Internet\DHCP;..\UserCode\Driver\Internet\DNS;..\UserCode\Fatfs\src;..\UserCode\E2pfs\src;..\UserCode\Driver\NRF24L01;..\UserCode\Driver\ESP8266;..\UserCode\Driver\HT1621;..\UserCode\Driver\AT24Cxx;..\UserCode\Driver\TPAD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32_Lib
    ../STM32_Lib/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
    ../STM32_Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c
  group UCOS II_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS II_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOS II_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group User
    ../UserCode/: user_main.c user_Task.c stm32f10x_it.c
  group App
    ../UserCode/App/: Debug.c Debug.h SignalLED.c SignalLED.h MsgManage.c CommNode.c CommNetUart.c 2_4GRF.c
  group Oper
    ../UserCode/DataOper/: Blank.c Blank.h BoxOs_str.c cmd_para.c CRC16.c hex_para.c RingQueue.c queue.c
  group Bsp
    ../UserCode/Driver/Bsp/: bsp.c bsp.h bsp_sys.c bsp_sys.h bsp_delay.c bsp_delay.h bsp_flash.c bsp_flash.h bsp_uart.c bsp_uart.h bsp_adc.c bsp_adc.h bsp_dma.c bsp_dma.h bsp_spi.c bsp_spi.h bsp_TiMbase.c bsp_TiMbase.h bsp_TiMpwm.c bsp_TiMpwm.h bsp_I2Csoft.c bsp_I2Csoft.h
  group NRF24L01
    ../UserCode/Driver/NRF24L01/: nrf24l01.c nrf24l01.h nrf24l01_conf.c nrf24l01_conf.h
  group E2pfs
    ../UserCode/E2pfs/src/: e2pio.c e2pio.h ef.c ef.h efconf.h
  group HT1621
    ../UserCode/Driver/HT1621/: ht1621.c ht1621.h ht1621_conf.c ht1621_conf.h
  group AT24Cxx
    ../UserCode/Driver/AT24Cxx/: at24cxx.c at24cxx.h at24cxx_conf.c at24cxx_conf.h
  group Tpad
    ../UserCode/Driver/TPAD/: tpad.c
  group README
    ../: README.TXT
  group cJSON
    ../UserCode/DataOper/cJSON/: cJSON.c test.c
